# IAR project GD32VW553H_EVAL.ewp, settings and files
configuration GD32VW55x (RISCV, debug)
  General.GDeviceSelect: GD32VW553xM GD GD32VW553xM
  General.GHeapSize: 0x1000
  ICCRISCV.IccLang: 0
  ICCRISCV.CCOptLevel: 3
  ICCRISCV.CCOptStrategy: 0
  ICCRISCV.CCDiagSuppress: Pe550,Pe188,Pe111,Pe546,Pa089,Pe236,Pe177,Pe191
  ICCRISCV.CCIncludePath2: ..\..\Utilities\bsp_drive; ..\..\Utilities\lvgl\lvgl; ..\..\Utilities\lvgl\lvgl_port; ..\..\Firmware\GD32VW55x_standard_peripheral\Include; ..\..\Firmware\GD32VW55x_standard_peripheral; ..\..\Firmware\RISCV\env_IAR; ..\..\Firmware\RISCV\drivers; ..; ..\GUI_APP\GD32EmbeddedUI; ..\GUI_APP\GD32EmbeddedUI\custom; ..\GUI_APP\GD32EmbeddedUI\generated
  OBJCOPY.OOCOutputFile: GD32VW553H_EVAL.srec
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: GD32VW553xM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../: gd32vw55x_it.c main.c systick.c
  group bsp_drive
    ../../Utilities/bsp_drive/: gd32vw553h_eval.c lcd_driver.c
  group CMSIS
    ../../Firmware/GD32VW55x_standard_peripheral/: system_gd32vw55x.c
  group Doc
    ../../: README.md
  group lvgl
    ../../Utilities/lvgl/lvgl/src/libs/barcode/: code128.c
    ../../Utilities/lvgl/lvgl/src/libs/frogfs/src/: decomp_raw.c frogfs.c
    ../../Utilities/lvgl/lvgl/src/libs/gif/: gif.c
    ../../Utilities/lvgl/lvgl/src/libs/lodepng/: lodepng.c
    ../../Utilities/lvgl/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_bidi_common.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_grad.c lv_iter.c lv_ll.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_pending.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../../Utilities/lvgl/lvgl/src/widgets/animimage/: lv_animimage.c
    ../../Utilities/lvgl/lvgl/src/widgets/property/: lv_animimage_properties.c lv_arc_properties.c lv_bar_properties.c lv_buttonmatrix_properties.c lv_chart_properties.c lv_checkbox_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_led_properties.c lv_line_properties.c lv_menu_properties.c lv_obj_properties.c lv_roller_properties.c lv_scale_properties.c lv_slider_properties.c lv_span_properties.c lv_spinbox_properties.c lv_spinner_properties.c lv_style_properties.c lv_switch_properties.c lv_table_properties.c lv_tabview_properties.c lv_textarea_properties.c
    ../../Utilities/lvgl/lvgl/src/widgets/arc/: lv_arc.c
    ../../Utilities/lvgl/lvgl/src/widgets/arclabel/: lv_arclabel.c
    ../../Utilities/lvgl/lvgl/src/widgets/bar/: lv_bar.c
    ../../Utilities/lvgl/lvgl/src/widgets/barcode/: lv_barcode.c
    ../../Utilities/lvgl/lvgl/src/image/: lv_bin_decoder.c lv_bmp.c lv_image_decoder.c lv_libjpeg_turbo.c lv_libpng.c lv_libwebp.c lv_lodepng.c lv_tjpgd.c
    ../../Utilities/lvgl/lvgl/src/font/binfont_loader/: lv_binfont_loader.c
    ../../Utilities/lvgl/lvgl/src/draw/sw/blend/arm2d/: lv_blend_arm2d.c
    ../../Utilities/lvgl/lvgl/src/widgets/button/: lv_button.c
    ../../Utilities/lvgl/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../../Utilities/lvgl/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../../Utilities/lvgl/lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ../../Utilities/lvgl/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../Utilities/lvgl/lvgl/src/widgets/canvas/: lv_canvas.c
    ../../Utilities/lvgl/lvgl/src/widgets/chart/: lv_chart.c
    ../../Utilities/lvgl/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../../Utilities/lvgl/lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
    ../../Utilities/lvgl/lvgl/src/display/: lv_display.c
    ../../Utilities/lvgl/lvgl/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_blur.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_utils.c lv_draw_vector.c
    ../../Utilities/lvgl/lvgl/src/draw/convert/: lv_draw_buf_convert.c
    ../../Utilities/lvgl/lvgl/src/draw/convert/helium/: lv_draw_buf_convert_helium.c
    ../../Utilities/lvgl/lvgl/src/draw/convert/neon/: lv_draw_buf_convert_neon.c
    ../../Utilities/lvgl/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blur.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_vector.c
    ../../Utilities/lvgl/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_a8.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../../Utilities/lvgl/lvgl/src/draw/sw/blend/neon/: lv_draw_sw_blend_neon_to_rgb565.c lv_draw_sw_blend_neon_to_rgb888.c
    ../../Utilities/lvgl/lvgl/src/draw/sw/blend/riscv_v/: lv_draw_sw_blend_riscv_v_to_rgb888.c
    ../../Utilities/lvgl/lvgl/src/draw/sw/blend/sve2/: lv_draw_sw_blend_sve2_to_rgb888.c
    ../../Utilities/lvgl/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../../Utilities/lvgl/lvgl/src/others/file_explorer/: lv_file_explorer.c
    ../../Utilities/lvgl/lvgl/src/layouts/flex/: lv_flex.c
    ../../Utilities/lvgl/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ../../Utilities/lvgl/lvgl/src/font/fmt_txt/: lv_font_fmt_txt.c
    ../../Utilities/lvgl/lvgl/src/font/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
    ../../Utilities/lvgl/lvgl/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../../Utilities/lvgl/lvgl/src/fs/: lv_fs.c lv_fs_fatfs.c lv_fs_frogfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_uefi.c lv_fs_win32.c
    ../../Utilities/lvgl/lvgl/src/widgets/gif/: lv_gif.c
    ../../Utilities/lvgl/lvgl/src/layouts/grid/: lv_grid.c
    ../../Utilities/lvgl/lvgl/src/indev/: lv_gridnav.c lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
    ../../Utilities/lvgl/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_observer.c lv_refr.c
    ../../Utilities/lvgl/lvgl/src/widgets/image/: lv_image.c
    ../../Utilities/lvgl/lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../../Utilities/lvgl/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../../Utilities/lvgl/lvgl/src/widgets/ime/: lv_ime_pinyin.c
    ../../Utilities/lvgl/lvgl/src/font/imgfont/: lv_imgfont.c
    ../../Utilities/lvgl/lvgl/src/: lv_init.c
    ../../Utilities/lvgl/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../../Utilities/lvgl/lvgl/src/widgets/label/: lv_label.c
    ../../Utilities/lvgl/lvgl/src/layouts/: lv_layout.c
    ../../Utilities/lvgl/lvgl/src/widgets/led/: lv_led.c
    ../../Utilities/lvgl/lvgl/src/widgets/line/: lv_line.c
    ../../Utilities/lvgl/lvgl/src/widgets/list/: lv_list.c
    ../../Utilities/lvgl/lvgl/src/logging/: lv_log.c
    ../../Utilities/lvgl/lvgl/src/stdlib/: lv_mem.c
    ../../Utilities/lvgl/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../../Utilities/lvgl/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../../Utilities/lvgl/lvgl/src/widgets/menu/: lv_menu.c
    ../../Utilities/lvgl/lvgl/src/debugging/monkey/: lv_monkey.c
    ../../Utilities/lvgl/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../../Utilities/lvgl/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../../Utilities/lvgl/lvgl/src/debugging/profiler/: lv_profiler_builtin.c lv_profiler_builtin_posix.c
    ../../Utilities/lvgl/lvgl/src/widgets/qrcode/: lv_qrcode.c
    ../../Utilities/lvgl/lvgl/src/libs/rle/: lv_rle.c
    ../../Utilities/lvgl/lvgl/src/widgets/roller/: lv_roller.c
    ../../Utilities/lvgl/lvgl/src/widgets/scale/: lv_scale.c
    ../../Utilities/lvgl/lvgl/src/widgets/slider/: lv_slider.c
    ../../Utilities/lvgl/lvgl/src/draw/snapshot/: lv_snapshot.c
    ../../Utilities/lvgl/lvgl/src/widgets/span/: lv_span.c
    ../../Utilities/lvgl/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../../Utilities/lvgl/lvgl/src/widgets/spinner/: lv_spinner.c
    ../../Utilities/lvgl/lvgl/src/image/svg/: lv_svg.c lv_svg_decoder.c lv_svg_parser.c lv_svg_render.c lv_svg_token.c
    ../../Utilities/lvgl/lvgl/src/widgets/switch/: lv_switch.c
    ../../Utilities/lvgl/lvgl/src/debugging/sysmon/: lv_sysmon.c
    ../../Utilities/lvgl/lvgl/src/widgets/table/: lv_table.c
    ../../Utilities/lvgl/lvgl/src/widgets/tabview/: lv_tabview.c
    ../../Utilities/lvgl/lvgl/src/debugging/test/: lv_test_display.c lv_test_display_egl.c lv_test_fs.c lv_test_helpers.c lv_test_indev.c lv_test_indev_gesture.c lv_test_screenshot_compare.c
    ../../Utilities/lvgl/lvgl/src/widgets/textarea/: lv_textarea.c
    ../../Utilities/lvgl/lvgl/src/themes/: lv_theme.c
    ../../Utilities/lvgl/lvgl/src/themes/default/: lv_theme_default.c
    ../../Utilities/lvgl/lvgl/src/themes/mono/: lv_theme_mono.c
    ../../Utilities/lvgl/lvgl/src/themes/simple/: lv_theme_simple.c
    ../../Utilities/lvgl/lvgl/src/tick/: lv_tick.c
    ../../Utilities/lvgl/lvgl/src/widgets/tileview/: lv_tileview.c
    ../../Utilities/lvgl/lvgl/src/font/tiny_ttf/: lv_tiny_ttf.c
    ../../Utilities/lvgl/lvgl/src/others/translation/: lv_translation.c
    ../../Utilities/lvgl/lvgl/src/widgets/win/: lv_win.c
    ../../Utilities/lvgl/lvgl/src/libs/lz4/: lz4.c
    ../../Utilities/lvgl/lvgl/src/libs/qrcode/: qrcodegen.c
    ../../Utilities/lvgl/lvgl/src/libs/tjpgd/: tjpgd.c
  group lvgl_port
    ../../Utilities/lvgl/lvgl_port/: lv_port_disp.c
  group Peripherals
    ../../Firmware/GD32VW55x_standard_peripheral/Source/: gd32vw55x_adc.c gd32vw55x_cau.c gd32vw55x_cau_aes.c gd32vw55x_cau_des.c gd32vw55x_cau_tdes.c gd32vw55x_crc.c gd32vw55x_dbg.c gd32vw55x_dma.c gd32vw55x_eclic.c gd32vw55x_efuse.c gd32vw55x_exti.c gd32vw55x_fmc.c gd32vw55x_fwdgt.c gd32vw55x_gpio.c gd32vw55x_hau.c gd32vw55x_hau_sha_md5.c gd32vw55x_i2c.c gd32vw55x_pkcau.c gd32vw55x_pmu.c gd32vw55x_qspi.c gd32vw55x_rcu.c gd32vw55x_rtc.c gd32vw55x_spi.c gd32vw55x_syscfg.c gd32vw55x_timer.c gd32vw55x_trng.c gd32vw55x_usart.c gd32vw55x_wwdgt.c
  group RISCV
    ../../Firmware/RISCV/env_IAR/: cstartup.s low_level_init.c
    ../../Firmware/RISCV/stubs/: write.c
  group ui_app
    ../GUI_APP/GD32EmbeddedUI/custom/: gui_app.c
  group ui_resource
    ../GUI_APP/GD32EmbeddedUI/generated/font/: font_notosanscjksc_regular_14_b49ae336.c font_notosanscjksc_regular_14_b49ae336_fb3f.c
    ../GUI_APP/GD32EmbeddedUI/generated/image/: img_20260805_153726_fit_44x44.c
  group ui_source
    ../GUI_APP/GD32EmbeddedUI/generated/lang/: aic_lang.c font_list.c
    ../GUI_APP/GD32EmbeddedUI/generated/screens/: event.c
    ../GUI_APP/GD32EmbeddedUI/generated/screens/screen/: screen.c screen_event.c
    ../GUI_APP/GD32EmbeddedUI/generated/screens/screen1/: screen_1.c screen_1_event.c
    ../GUI_APP/GD32EmbeddedUI/generated/screens/screen2/: screen_2.c screen_2_event.c
    ../GUI_APP/GD32EmbeddedUI/generated/theme/: theme.c
    ../GUI_APP/GD32EmbeddedUI/generated/: ui_init.c ui_util.c
